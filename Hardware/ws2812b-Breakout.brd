# Repository sparkfun/WS2812_Breakout

File README.md:

SparkFun WS2812 RGB LED Breakout
========================

[*SparkFun WS2812 RGB LED Breakout(BOB-11820)*](https://www.sparkfun.com/products/11820)

This is a breakout board for the built-in WS2812 RGB LED. 
The WS2812 is actually an RGB LED with a WS2811 built right into the LED. 

Repository Contents
-------------------

* **/Firmware** - Example Arduino Sketch
* **/Hardware** - All Eagle design files (.brd, .sch)
* **/Production** - Test bed files and production panel files

Documentation
--------------
* **[Hookup Guide](https://learn.sparkfun.com/tutorials/ws2812-breakout-hookup-guide)** - Basic hookup guide for the WS2812 Breakout.
* **[SparkFun Fritzing repo](https://github.com/sparkfun/Fritzing_Parts)** - Fritzing diagrams for SparkFun products.
* **[SparkFun 3D Model repo](https://github.com/sparkfun/3D_Models)** - 3D models of SparkFun products. 

Product Versions
----------------
* [BOB-11820](https://www.sparkfun.com/products/retired/11820)- Version 1.0. Retired.
* [BOB-10504] (https://www.sparkfun.com/products/retired/10504)- Version 1.1. Retired. 

Version History
---------------
* [v1.1b](https://github.com/sparkfun/WS2812_Breakout/tree/V_1.1b) - Version 1.1b GitHub files. Current version. 
* [v1.1](https://github.com/sparkfun/WS2812_Breakout/tree/V_1.1) - Version 1.1 GitHub files. Retired. 
* [v1.0](https://github.com/sparkfun/WS2812_Breakout/tree/V_1.0) - Version 1.0 GitHub files. Retired. 

License Information
-------------------

This product is _**open source**_! 

Please review the LICENSE.md file for license information. 

If you have any questions or concerns on licensing, please contact techsupport@sparkfun.com.

Distributed as-is; no warranty is given.

- Your friends at SparkFun.

## EAGLE design Hardware/ws2812b-Breakout.brd

Parts:
C1: 0.1uF; 0603-CAP
FID1, FID2: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
JP1: INPUT; 1X03
JP2: OUTPUT; 1X03
JP4, JP15: STAND-OFF
LOGO1: OSHW-LOGOS; OSHW-LOGO-S
LOGO2: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
U1: WS2812B

Connections:
DI: JP1.2, U1.4 (DIN)
DO: JP2.2, U1.2 (DOUT)
GND: C1.1, JP1.1, JP2.1, U1.3 (VSS)
VCC: C1.2, JP1.3, JP2.3, U1.1 (VDD)

Notes on the sheet:
v11
N. Seidle
Revised by: Patrick Alberts
VCC: 3.5v to 5.3v

Board: 2 copper layers, 17.8 x 12.7 mm, 11 parts (2 on the bottom side), 4 nets.

## EAGLE design Hardware/ws2812-Breakout.brd

Parts:
C1: 0.1uF; 0603-CAP
FID1, FID2: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
JP1, JP4: STAND-OFF
JP3: LOGO-SFESK; SFE-LOGO-FLAME
JP10: INPUT; 1X03
JP11: OUTPUT; 1X03
LOGO1: OSHW-LOGOS; OSHW-LOGO-S
U1: LED-TRICOLOR-5050; LED-TRICOLOR-5050-IC

Connections:
DI: JP10.2, U1.2 (DI)
DO: JP11.2, U1.1 (DO)
GND: C1.1, JP10.1, JP11.1, U1.6 (VSS)
VCC: C1.2, JP10.3, JP11.3, U1.3 (VDD), U1.5 (VDD)

Notes on the sheet:
v10
N. Seidle

Board: 2 copper layers, 17.8 x 12.7 mm, 11 parts (2 on the bottom side), 4 nets.

## EAGLE design Production/WS2812B-Breakout-Panel-v11.brd

Board: 2 copper layers, 122.9 x 118.9 mm, 483 parts (96 on the bottom side), 192 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48: 0.1uF; 0603-CAP
E$1: FIDUCIAL-1.5X3
E$4, E$5: FIDUCIAL-1X2
FID1, FID2, FID3, FID4, FID5, FID6, FID7, FID8, FID9, FID10, FID11, FID12, FID13, FID14, FID15, FID16, FID17, FID18, FID19, FID20, FID21, FID22, FID23, FID24, FID25, FID26, FID27, FID28, FID29, FID30, FID31, FID32, FID33, FID34, FID35, FID36, FID37, FID38, FID39, FID40, FID41, FID42, FID43, FID44, FID45, FID46, FID47, FID48, FID49, FID50, FID51, FID52, FID53, FID54, FID55, FID56, FID57, FID58, FID59, FID60, FID61, FID62, FID63, FID64, FID65, FID66, FID67, FID68, FID69, FID70, FID71, FID72, FID73, FID74, FID75, FID76, FID77, FID78, FID79, FID80, FID81, FID82, FID83, FID84, FID85, FID86, FID87, FID88, FID89, FID90, FID91, FID92, FID93, FID94, FID95, FID96: FIDUCIAL1X2; FIDUCIAL-1X2
JP1, JP6, JP10, JP14, JP19, JP23, JP27, JP31, JP35, JP39, JP43, JP47, JP51, JP55, JP59, JP63, JP67, JP71, JP75, JP79, JP83, JP87, JP91, JP95, JP99, JP103, JP107, JP111, JP115, JP119, JP123, JP127, JP131, JP135, JP139, JP143, JP147, JP151, JP155, JP159, JP163, JP167, JP171, JP175, JP179, JP183, JP187, JP191: INPUT; 1X03
JP2, JP7, JP11, JP16, JP20, JP24, JP28, JP32, JP36, JP40, JP44, JP48, JP52, JP56, JP60, JP64, JP68, JP72, JP76, JP80, JP84, JP88, JP92, JP96, JP100, JP104, JP108, JP112, JP116, JP120, JP124, JP128, JP132, JP136, JP140, JP144, JP148, JP152, JP156, JP160, JP164, JP168, JP172, JP176, JP180, JP184, JP188, JP192: OUTPUT; 1X03
JP3, JP4, JP5, JP8, JP9, JP12, JP13, JP15, JP17, JP18, JP21, JP22, JP25, JP26, JP29, JP30, JP33, JP34, JP37, JP38, JP41, JP42, JP45, JP46, JP49, JP50, JP53, JP54, JP57, JP58, JP61, JP62, JP65, JP66, JP69, JP70, JP73, JP74, JP77, JP78, JP81, JP82, JP85, JP86, JP89, JP90, JP93, JP94, JP97, JP98, JP101, JP102, JP105, JP106, JP109, JP110, JP113, JP114, JP117, JP118, JP121, JP122, JP125, JP126, JP129, JP130, JP133, JP134, JP137, JP138, JP141, JP142, JP145, JP146, JP149, JP150, JP153, JP154, JP157, JP158, JP161, JP162, JP165, JP166, JP169, JP170, JP173, JP174, JP177, JP178, JP181, JP182, JP185, JP186, JP189, JP190: STAND-OFF
LOGO1, LOGO3, LOGO5, LOGO7, LOGO9, LOGO11, LOGO13, LOGO15, LOGO17, LOGO19, LOGO21, LOGO23, LOGO25, LOGO27, LOGO29, LOGO31, LOGO33, LOGO35, LOGO37, LOGO39, LOGO41, LOGO43, LOGO45, LOGO47, LOGO49, LOGO51, LOGO53, LOGO55, LOGO57, LOGO59, LOGO61, LOGO63, LOGO65, LOGO67, LOGO69, LOGO71, LOGO73, LOGO75, LOGO77, LOGO79, LOGO81, LOGO83, LOGO85, LOGO87, LOGO89, LOGO91, LOGO93, LOGO95: OSHW-LOGOS; OSHW-LOGO-S
LOGO2, LOGO4, LOGO6, LOGO8, LOGO10, LOGO12, LOGO14, LOGO16, LOGO18, LOGO20, LOGO22, LOGO24, LOGO26, LOGO28, LOGO30, LOGO32, LOGO34, LOGO36, LOGO38, LOGO40, LOGO42, LOGO44, LOGO46, LOGO48, LOGO50, LOGO52, LOGO54, LOGO56, LOGO58, LOGO60, LOGO62, LOGO64, LOGO66, LOGO68, LOGO70, LOGO72, LOGO74, LOGO76, LOGO78, LOGO80, LOGO82, LOGO84, LOGO86, LOGO88, LOGO90, LOGO92, LOGO94, LOGO96: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48: WS2812B

Connections:
DI: JP1.2, U1.4
DI1: JP6.2, U2.4
DI2: JP10.2, U3.4
DI3: JP14.2, U4.4
DI4: JP19.2, U5.4
DI5: JP23.2, U6.4
DI6: JP27.2, U7.4
DI7: JP31.2, U8.4
DI8: JP35.2, U9.4
DI9: JP39.2, U10.4
DI10: JP43.2, U11.4
DI11: JP47.2, U12.4
DI12: JP51.2, U13.4
DI13: JP55.2, U14.4
DI14: JP59.2, U15.4
DI15: JP63.2, U16.4
DI16: JP67.2, U17.4
DI17: JP71.2, U18.4
DI18: JP75.2, U19.4
DI19: JP79.2, U20.4
DI20: JP83.2, U21.4
DI21: JP87.2, U22.4
DI22: JP91.2, U23.4
DI23: JP95.2, U24.4
DI24: JP99.2, U25.4
DI25: JP103.2, U26.4
DI26: JP107.2, U27.4
DI27: JP111.2, U28.4
DI28: JP115.2, U29.4
DI29: JP119.2, U30.4
DI30: JP123.2, U31.4
DI31: JP127.2, U32.4
DI32: JP131.2, U33.4
DI33: JP135.2, U34.4
DI34: JP139.2, U35.4
DI35: JP143.2, U36.4
DI36: JP147.2, U37.4
DI37: JP151.2, U38.4
DI38: JP155.2, U39.4
DI39: JP159.2, U40.4
DI40: JP163.2, U41.4
DI41: JP167.2, U42.4
DI42: JP171.2, U43.4
DI43: JP175.2, U44.4
DI44: JP179.2, U45.4
DI45: JP183.2, U46.4
DI46: JP187.2, U47.4
DI47: JP191.2, U48.4
DO: JP2.2, U1.2
DO1: JP7.2, U2.2
DO2: JP11.2, U3.2
DO3: JP16.2, U4.2
DO4: JP20.2, U5.2
DO5: JP24.2, U6.2
DO6: JP28.2, U7.2
DO7: JP32.2, U8.2
DO8: JP36.2, U9.2
DO9: JP40.2, U10.2
DO10: JP44.2, U11.2
DO11: JP48.2, U12.2
DO12: JP52.2, U13.2
DO13: JP56.2, U14.2
DO14: JP60.2, U15.2
DO15: JP64.2, U16.2
DO16: JP68.2, U17.2
DO17: JP72.2, U18.2
DO18: JP76.2, U19.2
DO19: JP80.2, U20.2
DO20: JP84.2, U21.2
DO21: JP88.2, U22.2
DO22: JP92.2, U23.2
DO23: JP96.2, U24.2
DO24: JP100.2, U25.2
DO25: JP104.2, U26.2
DO26: JP108.2, U27.2
DO27: JP112.2, U28.2
DO28: JP116.2, U29.2
DO29: JP120.2, U30.2
DO30: JP124.2, U31.2
DO31: JP128.2, U32.2
DO32: JP132.2, U33.2
DO33: JP136.2, U34.2
DO34: JP140.2, U35.2
DO35: JP144.2, U36.2
DO36: JP148.2, U37.2
DO37: JP152.2, U38.2
DO38: JP156.2, U39.2
DO39: JP160.2, U40.2
DO40: JP164.2, U41.2
DO41: JP168.2, U42.2
DO42: JP172.2, U43.2
DO43: JP176.2, U44.2
DO44: JP180.2, U45.2
DO45: JP184.2, U46.2
DO46: JP188.2, U47.2
DO47: JP192.2, U48.2
GND: C1.1, JP1.1, JP2.1, U1.3
GND1: C2.1, JP6.1, JP7.1, U2.3
GND2: C3.1, JP10.1, JP11.1, U3.3
GND3: C4.1, JP14.1, JP16.1, U4.3
GND4: C5.1, JP19.1, JP20.1, U5.3
GND5: C6.1, JP23.1, JP24.1, U6.3
GND6: C7.1, JP27.1, JP28.1, U7.3
GND7: C8.1, JP31.1, JP32.1, U8.3
GND8: C9.1, JP35.1, JP36.1, U9.3
GND9: C10.1, JP39.1, JP40.1, U10.3
GND10: C11.1, JP43.1, JP44.1, U11.3
GND11: C12.1, JP47.1, JP48.1, U12.3
GND12: C13.1, JP51.1, JP52.1, U13.3
GND13: C14.1, JP55.1, JP56.1, U14.3
GND14: C15.1, JP59.1, JP60.1, U15.3
GND15: C16.1, JP63.1, JP64.1, U16.3
GND16: C17.1, JP67.1, JP68.1, U17.3
GND17: C18.1, JP71.1, JP72.1, U18.3
GND18: C19.1, JP75.1, JP76.1, U19.3
GND19: C20.1, JP79.1, JP80.1, U20.3
GND20: C21.1, JP83.1, JP84.1, U21.3
GND21: C22.1, JP87.1, JP88.1, U22.3
GND22: C23.1, JP91.1, JP92.1, U23.3
GND23: C24.1, JP95.1, JP96.1, U24.3
GND24: C25.1, JP99.1, JP100.1, U25.3
GND25: C26.1, JP103.1, JP104.1, U26.3
GND26: C27.1, JP107.1, JP108.1, U27.3
GND27: C28.1, JP111.1, JP112.1, U28.3
GND28: C29.1, JP115.1, JP116.1, U29.3
GND29: C30.1, JP119.1, JP120.1, U30.3
GND30: C31.1, JP123.1, JP124.1, U31.3
GND31: C32.1, JP127.1, JP128.1, U32.3
GND32: C33.1, JP131.1, JP132.1, U33.3
GND33: C34.1, JP135.1, JP136.1, U34.3
GND34: C35.1, JP139.1, JP140.1, U35.3
GND35: C36.1, JP143.1, JP144.1, U36.3
GND36: C37.1, JP147.1, JP148.1, U37.3
GND37: C38.1, JP151.1, JP152.1, U38.3
GND38: C39.1, JP155.1, JP156.1, U39.3
GND39: C40.1, JP159.1, JP160.1, U40.3
GND40: C41.1, JP163.1, JP164.1, U41.3
GND41: C42.1, JP167.1, JP168.1, U42.3
GND42: C43.1, JP171.1, JP172.1, U43.3
GND43: C44.1, JP175.1, JP176.1, U44.3
GND44: C45.1, JP179.1, JP180.1, U45.3
GND45: C46.1, JP183.1, JP184.1, U46.3
GND46: C47.1, JP187.1, JP188.1, U47.3
GND47: C48.1, JP191.1, JP192.1, U48.3
VCC: C1.2, JP1.3, JP2.3, U1.1
VCC1: C2.2, JP6.3, JP7.3, U2.1
VCC2: C3.2, JP10.3, JP11.3, U3.1
VCC3: C4.2, JP14.3, JP16.3, U4.1
VCC4: C5.2, JP19.3, JP20.3, U5.1
VCC5: C6.2, JP23.3, JP24.3, U6.1
VCC6: C7.2, JP27.3, JP28.3, U7.1
VCC7: C8.2, JP31.3, JP32.3, U8.1
VCC8: C9.2, JP35.3, JP36.3, U9.1
VCC9: C10.2, JP39.3, JP40.3, U10.1
VCC10: C11.2, JP43.3, JP44.3, U11.1
VCC11: C12.2, JP47.3, JP48.3, U12.1
VCC12: C13.2, JP51.3, JP52.3, U13.1
VCC13: C14.2, JP55.3, JP56.3, U14.1
VCC14: C15.2, JP59.3, JP60.3, U15.1
VCC15: C16.2, JP63.3, JP64.3, U16.1
VCC16: C17.2, JP67.3, JP68.3, U17.1
VCC17: C18.2, JP71.3, JP72.3, U18.1
VCC18: C19.2, JP75.3, JP76.3, U19.1
VCC19: C20.2, JP79.3, JP80.3, U20.1
VCC20: C21.2, JP83.3, JP84.3, U21.1
VCC21: C22.2, JP87.3, JP88.3, U22.1
VCC22: C23.2, JP91.3, JP92.3, U23.1
VCC23: C24.2, JP95.3, JP96.3, U24.1
VCC24: C25.2, JP99.3, JP100.3, U25.1
VCC25: C26.2, JP103.3, JP104.3, U26.1
VCC26: C27.2, JP107.3, JP108.3, U27.1
VCC27: C28.2, JP111.3, JP112.3, U28.1
VCC28: C29.2, JP115.3, JP116.3, U29.1
VCC29: C30.2, JP119.3, JP120.3, U30.1
VCC30: C31.2, JP123.3, JP124.3, U31.1
VCC31: C32.2, JP127.3, JP128.3, U32.1
VCC32: C33.2, JP131.3, JP132.3, U33.1
VCC33: C34.2, JP135.3, JP136.3, U34.1
VCC34: C35.2, JP139.3, JP140.3, U35.1
VCC35: C36.2, JP143.3, JP144.3, U36.1
VCC36: C37.2, JP147.3, JP148.3, U37.1
VCC37: C38.2, JP151.3, JP152.3, U38.1
VCC38: C39.2, JP155.3, JP156.3, U39.1
VCC39: C40.2, JP159.3, JP160.3, U40.1
VCC40: C41.2, JP163.3, JP164.3, U41.1
VCC41: C42.2, JP167.3, JP168.3, U42.1
VCC42: C43.2, JP171.3, JP172.3, U43.1
VCC43: C44.2, JP175.3, JP176.3, U44.1
VCC44: C45.2, JP179.3, JP180.3, U45.1
VCC45: C46.2, JP183.3, JP184.3, U46.1
VCC46: C47.2, JP187.3, JP188.3, U47.1
VCC47: C48.2, JP191.3, JP192.3, U48.1

## EAGLE design Production/ws2811-Breakout-Panel-v10.brd

Board: 2 copper layers, 90.9 x 105.2 mm, 400 parts (80 on the bottom side), 160 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40: 0.1uF; 0603-CAP
FID1, FID2, FID3, FID4, FID5, FID6, FID7, FID8, FID9, FID10, FID11, FID12, FID13, FID14, FID15, FID16, FID17, FID18, FID19, FID20, FID21, FID22, FID23, FID24, FID25, FID26, FID27, FID28, FID29, FID30, FID31, FID32, FID33, FID34, FID35, FID36, FID37, FID38, FID39, FID40, FID41, FID42, FID43, FID44, FID45, FID46, FID47, FID48, FID49, FID50, FID51, FID52, FID53, FID54, FID55, FID56, FID57, FID58, FID59, FID60, FID61, FID62, FID63, FID64, FID65, FID66, FID67, FID68, FID69, FID70, FID71, FID72, FID73, FID74, FID75, FID76, FID77, FID78, FID79, FID80: FIDUCIALUFIDUCIAL; MICRO-FIDUCIAL
JP1, JP4, JP5, JP6, JP12, JP13, JP17, JP18, JP22, JP23, JP27, JP28, JP32, JP33, JP37, JP38, JP42, JP43, JP47, JP48, JP52, JP53, JP57, JP58, JP62, JP63, JP67, JP68, JP72, JP73, JP77, JP78, JP82, JP83, JP87, JP88, JP92, JP93, JP97, JP98, JP102, JP103, JP107, JP108, JP112, JP113, JP117, JP118, JP122, JP123, JP127, JP128, JP132, JP133, JP137, JP138, JP142, JP143, JP147, JP148, JP152, JP153, JP157, JP158, JP162, JP163, JP167, JP168, JP172, JP173, JP177, JP178, JP182, JP183, JP187, JP188, JP192, JP193, JP197, JP198: STAND-OFF
JP2, JP3, JP9, JP16, JP21, JP26, JP31, JP36, JP41, JP46, JP51, JP56, JP61, JP66, JP71, JP76, JP81, JP86, JP91, JP96, JP101, JP106, JP111, JP116, JP121, JP126, JP131, JP136, JP141, JP146, JP151, JP156, JP161, JP166, JP171, JP176, JP181, JP186, JP191, JP196: LOGO-SFESK; SFE-LOGO-FLAME
JP7, JP10, JP14, JP19, JP24, JP29, JP34, JP39, JP44, JP49, JP54, JP59, JP64, JP69, JP74, JP79, JP84, JP89, JP94, JP99, JP104, JP109, JP114, JP119, JP124, JP129, JP134, JP139, JP144, JP149, JP154, JP159, JP164, JP169, JP174, JP179, JP184, JP189, JP194, JP199: INPUT; 1X03
JP8, JP11, JP15, JP20, JP25, JP30, JP35, JP40, JP45, JP50, JP55, JP60, JP65, JP70, JP75, JP80, JP85, JP90, JP95, JP100, JP105, JP110, JP115, JP120, JP125, JP130, JP135, JP140, JP145, JP150, JP155, JP160, JP165, JP170, JP175, JP180, JP185, JP190, JP195, JP200: OUTPUT; 1X03
LOGO1, LOGO2, LOGO3, LOGO4, LOGO5, LOGO6, LOGO7, LOGO8, LOGO9, LOGO10, LOGO11, LOGO12, LOGO13, LOGO14, LOGO15, LOGO16, LOGO17, LOGO18, LOGO19, LOGO20, LOGO21, LOGO22, LOGO23, LOGO24, LOGO25, LOGO26, LOGO27, LOGO28, LOGO29, LOGO30, LOGO31, LOGO32, LOGO33, LOGO34, LOGO35, LOGO36, LOGO37, LOGO38, LOGO39, LOGO40: OSHW-LOGOS; OSHW-LOGO-S
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40: LED-TRICOLOR-5050; LED-TRICOLOR-5050-IC

Connections:
DI: JP10.2, U1.2
DI1: JP7.2, U2.2
DI2: JP14.2, U3.2
DI3: JP19.2, U4.2
DI4: JP24.2, U5.2
DI5: JP29.2, U6.2
DI6: JP34.2, U7.2
DI7: JP39.2, U8.2
DI8: JP44.2, U9.2
DI9: JP49.2, U10.2
DI10: JP54.2, U11.2
DI11: JP59.2, U12.2
DI12: JP64.2, U13.2
DI13: JP69.2, U14.2
DI14: JP74.2, U15.2
DI15: JP79.2, U16.2
DI16: JP84.2, U17.2
DI17: JP89.2, U18.2
DI18: JP94.2, U19.2
DI19: JP99.2, U20.2
DI20: JP104.2, U21.2
DI21: JP109.2, U22.2
DI22: JP114.2, U23.2
DI23: JP119.2, U24.2
DI24: JP124.2, U25.2
DI25: JP129.2, U26.2
DI26: JP134.2, U27.2
DI27: JP139.2, U28.2
DI28: JP144.2, U29.2
DI29: JP149.2, U30.2
DI30: JP154.2, U31.2
DI31: JP159.2, U32.2
DI32: JP164.2, U33.2
DI33: JP169.2, U34.2
DI34: JP174.2, U35.2
DI35: JP179.2, U36.2
DI36: JP184.2, U37.2
DI37: JP189.2, U38.2
DI38: JP194.2, U39.2
DI39: JP199.2, U40.2
DO: JP11.2, U1.1
DO1: JP8.2, U2.1
DO2: JP15.2, U3.1
DO3: JP20.2, U4.1
DO4: JP25.2, U5.1
DO5: JP30.2, U6.1
DO6: JP35.2, U7.1
DO7: JP40.2, U8.1
DO8: JP45.2, U9.1
DO9: JP50.2, U10.1
DO10: JP55.2, U11.1
DO11: JP60.2, U12.1
DO12: JP65.2, U13.1
DO13: JP70.2, U14.1
DO14: JP75.2, U15.1
DO15: JP80.2, U16.1
DO16: JP85.2, U17.1
DO17: JP90.2, U18.1
DO18: JP95.2, U19.1
DO19: JP100.2, U20.1
DO20: JP105.2, U21.1
DO21: JP110.2, U22.1
DO22: JP115.2, U23.1
DO23: JP120.2, U24.1
DO24: JP125.2, U25.1
DO25: JP130.2, U26.1
DO26: JP135.2, U27.1
DO27: JP140.2, U28.1
DO28: JP145.2, U29.1
DO29: JP150.2, U30.1
DO30: JP155.2, U31.1
DO31: JP160.2, U32.1
DO32: JP165.2, U33.1
DO33: JP170.2, U34.1
DO34: JP175.2, U35.1
DO35: JP180.2, U36.1
DO36: JP185.2, U37.1
DO37: JP190.2, U38.1
DO38: JP195.2, U39.1
DO39: JP200.2, U40.1
GND: C1.1, JP10.1, JP11.1, U1.6
GND1: C2.1, JP7.1, JP8.1, U2.6
GND2: C3.1, JP14.1, JP15.1, U3.6
GND3: C4.1, JP19.1, JP20.1, U4.6
GND4: C5.1, JP24.1, JP25.1, U5.6
GND5: C6.1, JP29.1, JP30.1, U6.6
GND6: C7.1, JP34.1, JP35.1, U7.6
GND7: C8.1, JP39.1, JP40.1, U8.6
GND8: C9.1, JP44.1, JP45.1, U9.6
GND9: C10.1, JP49.1, JP50.1, U10.6
GND10: C11.1, JP54.1, JP55.1, U11.6
GND11: C12.1, JP59.1, JP60.1, U12.6
GND12: C13.1, JP64.1, JP65.1, U13.6
GND13: C14.1, JP69.1, JP70.1, U14.6
GND14: C15.1, JP74.1, JP75.1, U15.6
GND15: C16.1, JP79.1, JP80.1, U16.6
GND16: C17.1, JP84.1, JP85.1, U17.6
GND17: C18.1, JP89.1, JP90.1, U18.6
GND18: C19.1, JP94.1, JP95.1, U19.6
GND19: C20.1, JP99.1, JP100.1, U20.6
GND20: C21.1, JP104.1, JP105.1, U21.6
GND21: C22.1, JP109.1, JP110.1, U22.6
GND22: C23.1, JP114.1, JP115.1, U23.6
GND23: C24.1, JP119.1, JP120.1, U24.6
GND24: C25.1, JP124.1, JP125.1, U25.6
GND25: C26.1, JP129.1, JP130.1, U26.6
GND26: C27.1, JP134.1, JP135.1, U27.6
GND27: C28.1, JP139.1, JP140.1, U28.6
GND28: C29.1, JP144.1, JP145.1, U29.6
GND29: C30.1, JP149.1, JP150.1, U30.6
GND30: C31.1, JP154.1, JP155.1, U31.6
GND31: C32.1, JP159.1, JP160.1, U32.6
GND32: C33.1, JP164.1, JP165.1, U33.6
GND33: C34.1, JP169.1, JP170.1, U34.6
GND34: C35.1, JP174.1, JP175.1, U35.6
GND35: C36.1, JP179.1, JP180.1, U36.6
GND36: C37.1, JP184.1, JP185.1, U37.6
GND37: C38.1, JP189.1, JP190.1, U38.6
GND38: C39.1, JP194.1, JP195.1, U39.6
GND39: C40.1, JP199.1, JP200.1, U40.6
VCC: C1.2, JP10.3, JP11.3, U1.3, U1.5
VCC1: C2.2, JP7.3, JP8.3, U2.3, U2.5
VCC2: C3.2, JP14.3, JP15.3, U3.3, U3.5
VCC3: C4.2, JP19.3, JP20.3, U4.3, U4.5
VCC4: C5.2, JP24.3, JP25.3, U5.3, U5.5
VCC5: C6.2, JP29.3, JP30.3, U6.3, U6.5
VCC6: C7.2, JP34.3, JP35.3, U7.3, U7.5
VCC7: C8.2, JP39.3, JP40.3, U8.3, U8.5
VCC8: C9.2, JP44.3, JP45.3, U9.3, U9.5
VCC9: C10.2, JP49.3, JP50.3, U10.3, U10.5
VCC10: C11.2, JP54.3, JP55.3, U11.3, U11.5
VCC11: C12.2, JP59.3, JP60.3, U12.3, U12.5
VCC12: C13.2, JP64.3, JP65.3, U13.3, U13.5
VCC13: C14.2, JP69.3, JP70.3, U14.3, U14.5
VCC14: C15.2, JP74.3, JP75.3, U15.3, U15.5
VCC15: C16.2, JP79.3, JP80.3, U16.3, U16.5
VCC16: C17.2, JP84.3, JP85.3, U17.3, U17.5
VCC17: C18.2, JP89.3, JP90.3, U18.3, U18.5
VCC18: C19.2, JP94.3, JP95.3, U19.3, U19.5
VCC19: C20.2, JP99.3, JP100.3, U20.3, U20.5
VCC20: C21.2, JP104.3, JP105.3, U21.3, U21.5
VCC21: C22.2, JP109.3, JP110.3, U22.3, U22.5
VCC22: C23.2, JP114.3, JP115.3, U23.3, U23.5
VCC23: C24.2, JP119.3, JP120.3, U24.3, U24.5
VCC24: C25.2, JP124.3, JP125.3, U25.3, U25.5
VCC25: C26.2, JP129.3, JP130.3, U26.3, U26.5
VCC26: C27.2, JP134.3, JP135.3, U27.3, U27.5
VCC27: C28.2, JP139.3, JP140.3, U28.3, U28.5
VCC28: C29.2, JP144.3, JP145.3, U29.3, U29.5
VCC29: C30.2, JP149.3, JP150.3, U30.3, U30.5
VCC30: C31.2, JP154.3, JP155.3, U31.3, U31.5
VCC31: C32.2, JP159.3, JP160.3, U32.3, U32.5
VCC32: C33.2, JP164.3, JP165.3, U33.3, U33.5
VCC33: C34.2, JP169.3, JP170.3, U34.3, U34.5
VCC34: C35.2, JP174.3, JP175.3, U35.3, U35.5
VCC35: C36.2, JP179.3, JP180.3, U36.3, U36.5
VCC36: C37.2, JP184.3, JP185.3, U37.3, U37.5
VCC37: C38.2, JP189.3, JP190.3, U38.3, U38.5
VCC38: C39.2, JP194.3, JP195.3, U39.3, U39.5
VCC39: C40.2, JP199.3, JP200.3, U40.3, U40.5

## Commit log

2013-03-15 Adding original design and new SMD LED with IC built in.
2013-03-15 Fixed DRC errors.
2013-03-15 Fixed errors for CAM.
2013-03-29 Renamed files to reflect proper WS2811 control IC.
    Breakout board works well. Updating repo to hand off to Joel/Mike H.
2013-03-29 Removing redundant eagle files.
2013-04-04 Updated Silk
    Changed name to WS2811 RGB LED Breakout
    Added open source hardware logo
2013-04-11 Fixed all erros posed by engineers
    Changed dimension to allow board to fit on .1 grid.
    Changed cap value and package.
    Used new frame on sch.
    Centered LED.
    Clean up repo.
    Added version code instead of date.
2013-04-11 Deleted a few extra files
    Deleted a few extra files
2013-04-11 Updated Version to correct V12
    changed V10 to V12 to reflect file name
2013-05-03 Changed silk size on top copper
    Changed silk size on top copper and fixed up the schematic to have
    flags on the I/O.
2013-05-06 v10 Ready for production
    Organized files/folders
    Added fiducial marks to design
    Created panel array of boards for manufacture
    v12 now tagged as v10 (initial production ready design)
2013-07-26 Updating repo structure, adding firmware, README and .gitignore
2013-07-26 Update README.md
    Added part description.
2013-07-26 Fixed Silk
    Fixed silk to say WS2812 instead of WS2811
2014-11-24 added ws2812b package, trace re routes
2014-11-24 deleted old files
2014-12-09 Added QC CL specifications, Updated LED Package
2015-01-07 Updated Frame / LED package.
2015-02-12 qc checklist items fixed
2015-02-12 Fixed qc issues
2015-02-17 changed fids to regular size
2015-02-17 created panel v11
2015-06-26 Cleaning up repo structure, names, adding license, updating readme
2025-06-27 Update README.md
    Updating link

Notices in the files:
parts and their libraries:
SparkFun-LED: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 3.0 License
SparkFun-Aesthetics: http://creativecommons.org/licenses/by-sa/3.0
